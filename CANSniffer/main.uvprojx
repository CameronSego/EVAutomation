# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./src/: main.c serial.c dssp.c pc_comm.c can.c list.h list.c
    C:/ti/TivaWare_C_Series-2.1.2.111/driverlib/rvmdk/: driverlib.lib
software components: Device:Startup 1.0.0
