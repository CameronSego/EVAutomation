# Keil uVision project PWMInject.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWMInject
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: C:\ti\TivaWare_C_Series-1.1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.cpp can.c
    C:/ti/TivaWare_C_Series-1.1/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
